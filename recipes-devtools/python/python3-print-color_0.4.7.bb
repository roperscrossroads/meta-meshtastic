SUMMARY = "Terminal colour-printing helper used by the meshtastic CLI's output"
HOMEPAGE = "https://github.com/xy3/print-color"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

PYPI_PACKAGE = "print_color"
SRC_URI[sha256sum] = "5f07ab99f45d1439c7b88a0930a775affcade40ad04259e2f77d18fd643d5328"

inherit pypi python_setuptools_build_meta
