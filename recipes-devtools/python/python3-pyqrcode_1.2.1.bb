SUMMARY = "QR code generator — meshtastic CLI's channel-URL QR output"
HOMEPAGE = "https://github.com/mnooner256/pyqrcode"
LICENSE = "BSD-3-Clause"

LIC_FILES_CHKSUM = "file://PKG-INFO;md5=02e1d57c98b8dd2bcc1fb78d46d3e153"

PYPI_PACKAGE = "PyQRCode"
SRC_URI[sha256sum] = "fdbf7634733e56b72e27f9bce46e4550b75a3a2c420414035cae9d9d26b234d5"

inherit pypi setuptools3
