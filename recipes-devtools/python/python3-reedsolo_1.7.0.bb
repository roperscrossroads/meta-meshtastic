SUMMARY = "Reed-Solomon error correction — esptool's flash-image ECC"
HOMEPAGE = "https://github.com/tomerfiliba/reedsolomon"
LICENSE = "Unlicense | MIT-0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ffde61aeb8917e70e0257e0a4b6d103c"

PYPI_PACKAGE = "reedsolo"
SRC_URI[sha256sum] = "c1359f02742751afe0f1c0de9f0772cc113835aa2855d2db420ea24393c87732"

inherit pypi setuptools3
